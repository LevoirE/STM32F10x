# Keil uVision project pro.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0xC000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: pro
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\FWlib\inc;..\CMSIS;..\User;..\FreeRTOS\Source\include;..\FreeRTOS\Source\portable\Keil\ARM_CM3;..\Drivers;..\STARTUPCODE
  asm include: ..\FreeRTOS\Source\include
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group USER
    ./: main.c
  group CMSIS
    ../CMSIS/: core_cm3.c system_stm32f10x.c stm32f10x_it.c
  group FWlib
    ../FWlib/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c
  group STARTUP
    ../STARTUPCODE/: startup_stm32f10x_hd.s
  group Drivers
    ../Drivers/: led.c
  group FreeRTOS
    ../FreeRTOS/Source/: tasks.c list.c queue.c
    ../FreeRTOS/Source/portable/Keil/ARM_CM3/: port.c
    ../FreeRTOS/Source/portable/MemMang/: heap_4.c
